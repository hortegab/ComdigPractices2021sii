options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: prueba
    output_language: python
    run_options: run
  states: {}

blocks:
- name: GainRx
  id: variable_qtgui_range
  parameters:
    label: Ganancia de USRP
    start: '0'
    step: '1'
    stop: '60'
    value: '0'
  states: {}
- name: N
  id: variable
  parameters:
    value: 1024*8
  states: {}
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: audio_gain
    start: '1'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: 'Frecuencia central '
    start: 88e6
    step: 50e3
    stop: 108.5e6
    value: 95.7e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '195312.5'
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 4,0,1,2
    label0: Modulated-Freq
    label1: Modulated-Time
    label2: Message
    label3: Constellatin
    label4: Eye Diagram
    num_tabs: '5'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(samp_rate/48000)
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/(N*samp_rate)]*N'
    type: float
    vlen: N
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    N: N
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  
          """vector averager. N is the lengh of the vector"""

          def __init__(self, N=8192):
              gr.sync_block.__init__(
                  self,
                  name='e_vec_averager_ff',   
                  in_sig=[(np.float32,N)],
                  out_sig=[(np.float32,N)]
              )
              self.N = N
              self.rows_counter=0
              self.sum=0

          def work(self, input_items, output_items):
              x=input_items[0]
              y=output_items[0]
              self.sum += np.sum(x, axis=0)
              self.rows_counter += len(x)
              y[:]=self.sum/self.rows_counter
              return len(output_items[0])
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[1]*N'
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/16
    win: firdes.WIN_HANN
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: Menu@3:3,1,1,1
    name: '"Complex Envelope Constellation"'
    size: '1024'
    type: complex
    width1: '8'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: N
    gui_hint: Menu@0:2,1,1,1
    name: '"Spectrum Analyzer"'
    showports: 'True'
    type: complex
    ymax: '-80'
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: Menu@1:3,1,1,1
    label1: I-Signal
    label2: Q-signal
    name: '"Complex Envelope Time Signal"'
    size: '200'
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: Menu@2:3,1,1,1
    label1: Audio
    name: Audio Signal assuming FM source
    size: '200'
    srate: '48000'
    type: float
    width1: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: Menu@0:3,1,1,1
    label1: PSD (Watts/Hz)
    name: '"PSD Analyzer"'
    vlen: N
    width1: '3'
    x_axis_label: '"f"'
    x_start: '-samp_rate/2'
    x_step: samp_rate/N
    x_units: '"Hz"'
    y_axis_label: '"Sx(f)"'
    y_units: '"Watss/Hz"'
    ymax: '3e-12'
    ymin: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: fc
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: GainRx
    iq_imbal_enb0: '""'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_fm_deemph_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_0_0, '0', analog_fm_deemph_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_1_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_1, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0_0, '0', analog_wfm_rcv_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0_1_0_0, '0']

metadata:
  file_format: 1
